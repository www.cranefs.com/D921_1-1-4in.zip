# Autodesk Inventor part: D921_1 1-4in
## iProperties
Created: 2011-03
Part Number: D921_1 1-4in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
